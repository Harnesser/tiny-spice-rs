* Build 002 example

I1 0 1 3   ; current flows from n+ through to n-
R1 1 2 5
R2 2 3 5
R3 2 0 10
R4 3 0 10

.control
  op
  print all
  quit
.endc

* v(1) = 3.300000e+01
* v(2) = 1.800000e+01
* v(3) = 1.200000e+01
