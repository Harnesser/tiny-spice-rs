Full-Wave Rectifier

V1 1 2 SIN(0 5 1e3) ; input voltage
V2 2 0 0  ; ground, and current measure

* full-wave rectifier
D1 1 3
D2 4 1
D3 2 3
D4 4 2

* Small caps across the diodes to prevent time-step-too-small
CD1 1 3 12pF
CD2 4 1 12pF
CD3 2 3 12pF
CD4 4 2 12pF

* Load
Rl 3 4 1k
Cl 3 4 1uF

.control
*  option reltol = 0.001
*  option abstol = 1e-12

  tran 100ns 2ms
  option ; ngspice only shows new values after analysis

  plot v(1,2) v(3,4) ; (ngspice)
.endc
