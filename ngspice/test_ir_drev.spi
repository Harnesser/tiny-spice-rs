* Build 003 example

I1 0 1 3   ; current flows from n+ through to n-
R1 1 0 10  ; about 5V on v(1)
D1 0 1     ; reverse-biased

.control
  op
  print all
  quit
.endc
