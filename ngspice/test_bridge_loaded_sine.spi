* Diode bridge

V1 1 2 SIN(0 3 1e3) ; input voltage
V2 2 0 0  ; ground, and current measure

* full-wave rectifier
D1 1 3
D2 4 1
D3 2 3
D4 4 2

* half-wave rectifier (high-side diode)
*D1 1 3
*VS 4 2 0

* half-wave rectifier (low-side diode)
VS 1 3 0
D1 4 2

* half-wave rectifier (2 series diodes)
D1A 1 5
D1B 5 3
VS 4 2 0

* half-wave rectifier (diode either side of load)
*D1 1 3
*D4 4 2

* Load
Rl 3 4 1k ;

.control
  tran 1us 2ms
  plot v(3) v(4)
  plot v(1) v(3,4)
.endc
