Voltage Controlled Sources

* Set up a control voltage
Isrc gnd ctl SIN(0, 3.0, 800)
R1 ctl gnd 1

* VCCS - voltage controlled current source with load
Gvccs gnd n1 ctl gnd 2
Rc n1 gnd 1

* VCVS - voltage controlled voltage source with load
Evcvs n2 gnd ctl gnd 3
Rv n2 gnd 10k

.control
  tran 1us 5ms
  plot v(ctl) v(n1) v(n2)
.endc
