* Build 003 example

I1 0 1 3   ; current flows from n+ through to n-
R1 1 0 2   ; about 5V on v(1)
R2 1 2 1k
D1 2 0     ; error, but a default model is used

.control
  op
  print all
  quit
.endc
