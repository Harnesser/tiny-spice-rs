Some tests on the SPICE deck reader

R 1 0 1k
R 2 8 1
C 5 6 0.32uF
V 1 9 0.1uV
I 9 0 1000kA
R 3 4 0.2134

.control
  op
.endc
